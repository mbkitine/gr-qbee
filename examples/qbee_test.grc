<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Mode_6_Debug</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>(4*loop_bw*zeta)/denom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha_0</value></param>
<param><key>value</key><value>2*math.exp(-zeta*loop_bw)*math.sinh(zeta*loop_bw)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>beta</value></param>
<param><key>value</key><value>(4*loop_bw*loop_bw)/denom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>beta_0</value></param>
<param><key>value</key><value>2 - alpha_0 - math.exp(-zeta*loop_bw)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cut_off</value></param>
<param><key>value</key><value>baud_rate*(mod_index + 1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>denom</value></param>
<param><key>value</key><value>(1.0 + 2.0*zeta*loop_bw + loop_bw*loop_bw)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_attenuation</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_bw</value></param>
<param><key>value</key><value>baud_rate/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_fc</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>436.8e6 - 1e6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>gain_ant</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>70</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_ant</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gaussian_taps</value></param>
<param><key>value</key><value>firdes.gaussian(nfilts, 1.0/float(sps), 0.35, 45*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gf_taps</value></param>
<param><key>value</key><value>firdes.gaussian(1,1.0/float(sps),0.35,nfilts*45)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>loop_bw</value></param>
<param><key>value</key><value>0.01</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod_index</value></param>
<param><key>value</key><value>1/1.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>p_squelch</value></param>
<param><key>value</key><value>-100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>'011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110011111100111111001111110'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, sps, 1.0/float(sps), 0.35, 25*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>baud_rate*sps*dec</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>squelch</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>p_squelch</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-120</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlating_attn</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>filter_attenuation</value></param>
<param><key>label</key><value>Filter Attenuation</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlating_bw</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>filter_bw</value></param>
<param><key>label</key><value>Transition bandwidth</value></param>
<param><key>max</key><value>baud_rate</value></param>
<param><key>min</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlating_fc</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>filter_fc</value></param>
<param><key>label</key><value>Filter Fc</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>min</key><value>-10000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zeta</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/mbkitine/Desktop/Signals/SE01/qbee50_20171227-071001_iq.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>5001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>195312</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_1</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>5002</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>psize</key><value>1000</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x000000</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_0</value></param>
<param><key>rolloff</key><value>0.9</value></param>
<param><key>w</key><value>0.02</value></param>
<param><key>filter_size</key><value>44</value></param>
<param><key>samps_per_sym</key><value>sps</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_hdlc_deframer_bp</key>
<param><key>id</key><value>digital_hdlc_deframer_bp_0</value></param>
<param><key>max</key><value>500</value></param>
<param><key>min</key><value>32</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>195312/48000</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>firdes.gaussian(1,1.0/float(sps),0.35,45)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math,cmath</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>cut_off</value></param>
<param><key>decim</key><value>dec</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>xlating_bw</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook_0</value></param>
<param><key>labels</key><value>['RX signal','Filtered Signal','PFB','Binary','TX signal']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>nwr_symbol_sync_xx</key>
<param><key>id</key><value>nwr_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>1.0</value></param>
<param><key>nfilters</key><value>128</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>nwr.interpolating_resampler.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>0.02</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>pfb_mf_taps</key><value>[]</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>constellation</key><value>digital.constellation_bpsk().base()</value></param>
<param><key>ted_type</key><value>nwr.timing_error_detector.TED_MENGALI_AND_DANDREA_GMSK</value></param>
</block>
<block>
<key>qbee_qbee_deframer</key>
<param><key>id</key><value>qbee_qbee_deframer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length_max</key><value>500</value></param>
<param><key>length_min</key><value>32</value></param>
</block>
<block>
<key>qbee_qbee_demodulator_fsk</key>
<param><key>id</key><value>qbee_qbee_demodulator_fsk_0</value></param>
<param><key>modulation_index</key><value>mod_index</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>qbee_qbee_nrzi_decoder</key>
<param><key>id</key><value>qbee_qbee_nrzi_decoder_0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>sliced_data</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>iq</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>agc</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>sliced_data</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>iq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>agc</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_2</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,0</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>20</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>RX Signal</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_3</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,1</value></param>
<param><key>peak_hold</key><value>True</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>5</value></param>
<param><key>samp_rate</key><value>samp_rate/dec</value></param>
<param><key>title</key><value>Filtered Signal</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_4</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,2</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate/5</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>window.blackmanharris</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>digital_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_udp_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>qbee_qbee_nrzi_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_hdlc_deframer_bp_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_fftsink2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qbee_qbee_demodulator_fsk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_symbol_sync_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_symbol_sync_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qbee_qbee_deframer_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>qbee_qbee_deframer_0</source_block_id><sink_block_id>blocks_socket_pdu_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>qbee_qbee_demodulator_fsk_0</source_block_id><sink_block_id>nwr_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qbee_qbee_nrzi_decoder_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qbee_qbee_nrzi_decoder_0</source_block_id><sink_block_id>digital_hdlc_deframer_bp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qbee_qbee_nrzi_decoder_0</source_block_id><sink_block_id>qbee_qbee_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>wxgui_fftsink2_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
